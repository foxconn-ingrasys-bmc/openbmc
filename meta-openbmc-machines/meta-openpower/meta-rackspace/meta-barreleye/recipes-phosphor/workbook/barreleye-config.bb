SUMMARY = "Barreleye board wiring"
DESCRIPTION = "Board wiring information for the Barreleye system."
HOMEPAGE = "http://github.com/SteveLinCH/skeleton"
PR = "r1"

SRCREV = "v10.30.100"
inherit config-in-skeleton
inherit obmc-phosphor-license
