SUMMARY = "hgx1 board wiring"
DESCRIPTION = "Board wiring information for the hgx1 system."
HOMEPAGE = "https://github.com/foxconn-ingrasys-bmc/skeleton"
PR = "r1"

SRCREV = "7b6027f44990d1a6e69aee2f2f2eb69e688aac16"
inherit config-in-skeleton
inherit obmc-phosphor-license
