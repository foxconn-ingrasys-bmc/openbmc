OBMC_IMAGE_EXTRA_INSTALL_append = " inventory-upload"
OBMC_IMAGE_EXTRA_INSTALL_append += " sntp"
