FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-Add-GpioLib-for-initial-GPIO-pins.patch"
