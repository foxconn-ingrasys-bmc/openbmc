SUMMARY = "StHelens board wiring"
DESCRIPTION = "Board wiring information for the StHelens system."
HOMEPAGE = "https://github.com/foxconn-bmc-ks/skeleton"
PR = "r1"

SRCREV = "18c7eb28dfacb95d40fb6c66139d0eca8eb8ca7b"
inherit config-in-skeleton
inherit obmc-phosphor-license
