DEPENDS += "i2c-tools"
SRCREV ?= "d47260e56acedf2424625a23e533c94dd9f30991"
SKELETON_URI ?= "git://github.com/foxconn-bmc-ks/skeleton;branch=foxconn-g2"
