SUMMARY = "OpenBMC i2craw command tool"
DESCRIPTION = "OpenBMC i2craw command tool."
PR = "r1"

inherit skeleton-sdbus
#inherit obmc-phosphor-dbus-service

SKELETON_DIR = "info"

