KBRANCH ?= "foxconn-dev-4.10"
LINUX_VERSION ?= "4.10.17"

SRCREV="bca762916e7208addefc2336ae326b80410d3c13"

require linux-obmc.inc
